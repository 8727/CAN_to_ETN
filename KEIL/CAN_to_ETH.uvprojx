# Keil uVision project CAN_to_ETH.uvprojx, settings and files
target CAN_to_ETH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_to_ETH +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\CAN_to_ETH;.\CMSIS\inc;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./CMSIS/StartUp/: startup_stm32f10x_md.s
  group Source
    ../SOURCE/src/: main.c setting.c rtc.c rs485.c Ee24cxx.c can.c
